# IAR project Logger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832_xxAA NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52832_XXAA
  ICCARM.CCIncludePath2: ..\Sources\HAL\Base\; ..\Sources\HAL\Core\; ..\Sources\HAL\OsSys\; ..\Sources\HAL\Port\; ..\Sources\HAL\I2c\; ..\Sources\HAL\Spi\; ..\Sources\System\Os\; ..\Sources\Drivers\CypFlash\; ..\Sources\Drivers\Nvm\; ..\Sources\Drivers\NxpAccel\; ..\Sources\Drivers\NxpBaro\; ..\Sources\Drivers\PPMin\; ..\Sources\Lib\Crc\; ..\Sources\Lib\Filters\; ..\Sources\Lib\Ifx\; ..\Sources\ApplicationBgnd\; ..\Sources\ApplicationRT\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Logger.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: nrf52832_xxaa.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group AppRtGroup
    ../Sources/ApplicationRT/: RtAppComm.c RtAppComm.h RtAppData.c RtAppData.h RtAppExample.c RtAppExample.h RtAppPack.c RtAppPack.h RtAppSensor.c RtAppSensor.h
  group Drivers
    ../Sources/Drivers/CypFlash/: CypFlash.c CypFlash.h
    ../Sources/Drivers/Nvm/: Nvm.c Nvm_Cfg.c
    ../Sources/Drivers/NVM/: Nvm.h Nvm_Cfg.h Nvm_Internals.h
    ../Sources/Drivers/NxpAccel/: NxpAccel.c NxpAccel.h
    ../Sources/Drivers/NxpBaro/: NxpBaro.c NxpBaro.h
    ../Sources/Drivers/PPMin/: PPMin.c PPMin.h
  group HAL
    ../Sources/HAL/Base/: base.h system_nrf52.c
    ../Sources/HAL/Adc/: HALAdc.c HALAdc.h
    ../Sources/HAL/Core/: HALcore.c HALcore.h
    ../Sources/HAL/I2c/: HALI2c.c HALI2c.h HALI2c_Cfg.h HALI2c_Internals.h
    ../Sources/HAL/OsSys/: HALOsSys.c HALOsSys.h HALOsSysIrq.c
    ../Sources/HAL/Port/: HALport.c HALport.h
    ../Sources/HAL/Spi/: HALSpi.c HALSpi.h HALSpi_Cfg.h HALSpi_Internals.h
    ../Sources/HAL/Uart/: HALUart.c HALUart.h
  group Lib
    ../Sources/Lib/Crc/: LibCrc.c LibCrc.h
    ../Sources/Lib/Filters/: LibFilters.c LibFilters.h
    ../Sources/Lib/Ifx/: LibIfx.c LibIfx.h
  group Startup
    ../Sources/Startup/: startup_nrf52832.s
  group System
    ../Sources/System/Main/: main.c
  group System/Os
    ../Sources/System/Os/: Os.c Os.h Os_Internals.h Os_Rt.c Os_Rt.h
