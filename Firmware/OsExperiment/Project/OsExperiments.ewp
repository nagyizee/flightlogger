# IAR project OsExperiments.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100RB ST STM32F100RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\Sources\HAL\Base\; ..\Sources\HAL\Core\; ..\Sources\HAL\OsSys\; ..\Sources\System\Os\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OsExperiments.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\nagyizee\Google Drive\Projects\My_Projects\FlightLogger\Firmware\OsExperiment\Project\stm32f100xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HAL
    ../Sources/HAL/Base/: base.h
    ../Sources/HAL/Core/: HALcore.c HALcore.h
    ../Sources/HAL/OsSys/: HALOsSys.c HALOsSys.h HALOsSysIrq.c
  group Startup
    ../Sources/Startup/: startup_stm32f100xb.s
  group System
    ../Sources/System/Main/: main.c
  group System/Os
    ../Sources/System/Os/: Os.c Os.h Os_Internals.h Os_Rt.c Os_Rt.h
